# Keil uVision project DC-Motor.uvproj, settings and files
target Target 1 (MCS-51)
  device: see Microchip Atmel Wireless & uC
  output: DC Motor +hex
  c flags: Optimize=8 SizeSpeed=1
