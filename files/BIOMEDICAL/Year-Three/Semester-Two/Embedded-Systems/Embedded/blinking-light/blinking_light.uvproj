# Keil uVision project blinking_light.uvproj, settings and files
target Target 1 (MCS-51)
  device: see NXP Philips
  output: blinking_light +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: blinking_light.c
