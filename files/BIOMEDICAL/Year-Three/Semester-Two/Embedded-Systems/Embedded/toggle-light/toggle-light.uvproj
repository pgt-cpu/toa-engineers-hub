# Keil uVision project toggle-light.uvproj, settings and files
target Target 1 (MCS-51)
  device: see Microchip Atmel Wireless & uC
  output: toggle light +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: toggle led.c
